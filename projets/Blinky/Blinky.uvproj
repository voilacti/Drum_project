# Keil uVision project Blinky.uvproj, settings and files
target STM32F103 Simulator (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\..\pilotes\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Files
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group System Files
    ./: Retarget.c
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group pilotes
    ../../pilotes/src/: adc.c clock.c fbuser.c gpio.c pwm.c timer_1234.c
target STM32F103 Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\..\pilotes\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
